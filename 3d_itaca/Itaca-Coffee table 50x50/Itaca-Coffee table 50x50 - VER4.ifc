Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Coffee table 50x50 - VER4.ifc
Time: 2025-11-13T15:47:08
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Itaca-Coffee table 50x50_0 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_1 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_2 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_3 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_4 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_5 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_6 - ObjectType: SketchupGroup
 | Itaca-Coffee table 50x50_7 - ObjectType: SketchupGroup
